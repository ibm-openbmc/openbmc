FILESEXTRAPATHS:prepend := "${THISDIR}/${PN}:"

SRC_URI += "file://0001-Add-helpers-for-DHCP-and-static-IP-management.patch"
