hostname_pn-base-files = "FP5295G2"
