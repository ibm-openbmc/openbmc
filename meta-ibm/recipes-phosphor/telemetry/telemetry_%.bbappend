EXTRA_OEMESON:append:p10bmc = " \
    -Dmax-reading-parameters=32768 \
"
