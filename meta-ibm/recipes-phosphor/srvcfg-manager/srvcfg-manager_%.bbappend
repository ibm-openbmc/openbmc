EXTRA_OEMESON:append:p10bmc = " \
    -Dusb-code-update=enabled \
"
