DEPENDS += "sbe-validation-error-native"
