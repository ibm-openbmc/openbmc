EXTRA_OEMESON_append_p10bmc += "-Dsystem-vpd-dependency=enabled"
