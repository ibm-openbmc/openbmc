EXTRA_OECONF_append_rainier = " MAX_CPUS=4"
