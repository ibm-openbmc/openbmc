KBRANCH ?= "op940-dev-6.1"
LINUX_VERSION ?= "6.1.30"

SRCREV="0c9470dc93e2a8c20df253583cd770475908275b"

require linux-aspeed.inc
