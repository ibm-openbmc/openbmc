hostboot_dump_temp_path = "/tmp/openpower-dumps/hostboot"

hostboot_dump_path = "/var/lib/phosphor-debug-collector/hostbootdump/"
