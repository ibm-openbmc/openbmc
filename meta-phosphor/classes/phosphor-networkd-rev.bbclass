SRC_URI += "git://github.com/ibm-openbmc/phosphor-networkd;branch=OP940;protocol=https"
SRCREV = "058d372c8095ba2fd7f592a91d9c1f0cd3070701"
