MRW_API_SRC_URI ?= "git://github.com/open-power/serverwiz.git"
MRW_API_SRCREV ?= "60c8e10cbb11768cd1ba394b35cb1d6627efec42"

MRW_TOOLS_SRC_URI ?= "git://github.com/openbmc/phosphor-mrw-tools"
MRW_TOOLS_SRCREV ?= "5102e57b12015a697b64b54c67d1146ab9afe5e7"
